<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cfreq</value></param>
<param><key>value</key><value>60</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>High-pass filter cutoff frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>hpf_gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>High-pass filter gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.01</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1.024e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_AM</value></param>
<param><key>value</key><value>int(64e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_ratio</value></param>
<param><key>value</key><value>int(samp_rate / samp_rate_AM)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>twind</value></param>
<param><key>value</key><value>20</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>High-pass filter transition window</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>500</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>MessageDecoder</value></param>
<param><key>bit_period</key><value>0.001</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import time

STATE_SYNC = 0
STATE_DATA = 1

DTYPE = np.float32

PATTERN_SYNC = [0,0,0,0, 1,1,1,1, 0,0,0,0]
PATTERN_BIT_0 = [1, 0, 1, 0]
PATTERN_BIT_1 = [1, 1, 0, 0]
PATTERN_BIT_END = [1, 1, 1, 1]
lens = [len(PATTERN_BIT_0), len(PATTERN_BIT_1), len(PATTERN_BIT_END)]
assert(min(lens) == max(lens))

def normalize(sig):
    '''Normalize a signal and return it'''
    norm = np.sqrt(np.sum(sig * sig))
    return sig / norm
class blk(gr.sync_block):
    def patternToSignal(self, pattern):
        protoSignal = []
        for bit in pattern:
            if bit == 0:
                bit = -1
            protoSignal += [bit] * self.bitSampleWidth
        return normalize(np.array(protoSignal, dtype=DTYPE))
    def __init__(self, samp_rate=64e3, sync_threshold=0.1, bit_period=1e-3):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Message Decoder (Python)',
            in_sig=[DTYPE],
            out_sig=[]
        )
        self.bitSampleWidth = int(bit_period * samp_rate)
#        self.sampleRate = 
        self.thresh = sync_threshold
        self.state = STATE_SYNC
#        self.bitPeriod = 
        self.decodeBufferSync = np.zeros(self.bitSampleWidth * len(PATTERN_SYNC), dtype=DTYPE)
        self.decodeBufferBit = np.zeros(self.bitSampleWidth * len(PATTERN_BIT_0), dtype=DTYPE)
        self.bufferIndex = 0

        self.pulseSync = self.patternToSignal(PATTERN_SYNC)
        self.pulseBit0 = self.patternToSignal(PATTERN_BIT_0)
        self.pulseBit1 = self.patternToSignal(PATTERN_BIT_1)
        self.pulseDesync = self.patternToSignal(PATTERN_BIT_END)
        
        self.message = ''
        self.nextPrint = 0
        self.debug = True

    def doMessage(self):
        now = time.time()
        print ('msgDecoded', self.message)
        if now &gt; self.nextPrint:
            print (self.message)
            self.nextPrint = now + 1
        self.message = ''
    def doSyncState(self, data):
        needed = len(self.decodeBufferSync) - self.bufferIndex
        usage = min(len(data), needed)
        for i in range(usage):
            self.decodeBufferSync[self.bufferIndex] = data[i]
            self.bufferIndex += 1
        assert(self.bufferIndex &lt;= len(self.decodeBufferSync))
        while self.bufferIndex &gt;= len(self.decodeBufferSync):
            # the buffer is full, compute on it
            # Pattern is already normalized, signal is not
            correlation = np.abs(np.dot(normalize(self.decodeBufferSync), self.pulseSync))
            if correlation &gt; self.thresh:
                print 'Sync!'
                self.bufferIndex = 0
                self.state = STATE_DATA
                return usage # found sync, return to change state
            else:
                np.roll(self.decodeBufferSync, -1) # shift left by 1
                if usage &lt; len(data): # roll in another sample and try correlating again
                    self.decodeBufferSync[-1] = data[usage]
                    usage += 1
                else: # out of data, return
                    self.bufferIndex -= 1
                    return usage
        assert(usage == len(data))
        return usage
    def doDataState(self, data):
        usage = 0
        while usage &lt; len(data):
            self.decodeBufferBit[self.bufferIndex] = data[usage]
            self.bufferIndex += 1
            usage += 1
            if self.bufferIndex &gt;= len(self.decodeBufferBit):
                # the buffer is full, compute on it
                signal = normalize(self.decodeBufferBit)
                corBit0 = np.abs(np.dot(self.pulseBit0, signal))
                corBit1 = np.abs(np.dot(self.pulseBit1, signal))
                corEnd = np.abs(np.dot(self.pulseDesync, signal))
                corMax = max(corBit0, corBit1, corEnd)
                
                if corEnd == corMax:
                    # finished message
                    self.state = STATE_SYNC
                    self.bufferIndex = 0
                    self.doMessage()
                    return usage
                
                if corBit0 == corMax:
                    self.message += '0'
                else:
                    self.message += '1'
                self.bufferIndex = 0
        return usage
        
    def work(self, input_items, output_items):
        return 0
        if self.debug:
            print ('#$#$ input data len', input_items[0], len(input_items[0]))
            self.debug = False
        dataUsed = 0
        while dataUsed &lt; len(input_items[0]):
            if self.state == STATE_SYNC:
                dataUsed += self.doSyncState(input_items[0][dataUsed:])
            elif self.state == STATE_DATA:
                dataUsed += self.doDataState(input_items[0][dataUsed:])
        return 0
        #output_items[0][:] = input_items[0]
        #return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>64000.0</value></param>
<param><key>sync_threshold</key><value>0.1</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>10000</value></param>
<param><key>audio_stop</key><value>10500</value></param>
<param><key>chan_rate</key><value>samp_rate_AM</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>5980</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/data.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>samp_rate_ratio</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>samp_rate_ratio</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>samp_rate_ratio</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>samp_rate_ratio</value></param>
<param><key>max_iter</key><value>4 * samp_rate_ratio</value></param>
<param><key>scale</key><value>1.0 / samp_rate_ratio</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>samp_rate_ratio</value></param>
<param><key>max_iter</key><value>4 * samp_rate_ratio</value></param>
<param><key>scale</key><value>1.0 / samp_rate_ratio</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>cfreq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>hpf_gain</value></param>
<param><key>samp_rate</key><value>samp_rate_AM</value></param>
<param><key>width</key><value>twind</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Downsampled"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_AM</value></param>
<param><key>tr_level</key><value>-0.45</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Custom Demod"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"AM Demod -&gt; HPF -&gt; this graph"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_AM</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"AM Demod -&gt; HPF -&gt; this graph"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_AM</value></param>
<param><key>tr_level</key><value>-0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"power"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_AM</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-0.01</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>433.92e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Raw"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Custom Demod"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.74e6</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>high_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>high_pass_filter_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>high_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
